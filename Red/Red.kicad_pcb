# Repository NathanRoseCE/RedBoard

## KiCad design Red/Red.kicad_pcb

Parts:
H101, H102: MountingHole; MountingHole_4.3mm_M4

Parts:
C201, C202: 10uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder; digikey 399-4925-1-ND
C203, C204: 22uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder; digikey 490-7611-1-ND
J201: Conn_01x02; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
U201: AZ1117-3.3; SOT-223; digikey AZ1117CH-3.3TRG1DICT-ND
U202: AZ1117-5.0; SOT-223; digikey AZ1117CH-5.0TRG1DICT-ND

Connections:
+3V3: C203.1, U201.2 (VO); also elsewhere on the board
+5V: C201.1, C204.1, U201.3 (VI), U202.2 (VO); also elsewhere on the board
+BATT: C202.1, J201.2, U202.3 (VI); also elsewhere on the board
GND: C201.2, C202.2, C203.2, C204.2, J201.1, U201.1 (GND), U202.1 (GND); also elsewhere on the board

Parts:
C301: 1mF; CP_Radial_D10.0mm_P5.00mm; digikey 1189-3703-1-ND
J301: Conn_01x03; WM4901-ND; digikey WM4901-ND
J302, J303: Screw_Terminal_01x02; 2_pin_screw_terminal; digikey A98333-ND
Q301, Q302, Q303, Q304, Q305: DMG3414U; SOT-23; digikey DMN1019USN-7DICT-ND
R301, R302, R303, R304, R305, R307: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder; digikey 311-10KGRCT-ND
R306, R308: 4.7; TO-263-2_TabPin1; digikey PWR263S-20-4R70J
e301: Conn_01x03; WM4901-ND; digikey WM4901-ND

Connections:
+5V: J301.2, Q301.3 (D), Q302.3 (D), e301.2; also elsewhere on the board
+BATT: C301.1, Q304.3 (D); also elsewhere on the board
/Microprocessor/ARM: Q304.1 (G); also elsewhere on the board
/Microprocessor/PWM1: Q301.1 (G), R301.1; also elsewhere on the board
/Microprocessor/PWM2: Q302.1 (G), R302.1; also elsewhere on the board
/Robotics/5V_PWM1: Q301.2 (S), R303.1, e301.1
/Robotics/5V_PWM2: J301.3, Q302.2 (S), R304.1
/Robotics/FIRE1: Q303.1 (G), R305.1; also elsewhere on the board
/Robotics/FIRE2: Q305.1 (G), R307.1; also elsewhere on the board
GND: C301.2, J301.1, R301.2, R302.2, R303.2, R304.2, R305.2, R306.2, R307.2, R308.2, e301.3; also elsewhere on the board
unnamed: J302.1, J303.1, Q304.2 (S)
unnamed: J302.2, Q303.3 (D)
unnamed: J303.2, Q305.3 (D)
unnamed: Q303.2 (S), R306.1
unnamed: Q305.2 (S), R308.1

Parts:
I401: MT25QL512ABB8ESF-0SIT; SOP-16_4.55x10.3mm_P1.27mm; digikey 557-1987-1-ND

Connections:
+3V3: I401.2 (Vcc); also elsewhere on the board
/FLash/CS: I401.7 (S#); also elsewhere on the board
/FLash/QSCLK: I401.16 (C); also elsewhere on the board
/FLash/QSPI_IO0: I401.15 (DQ0); also elsewhere on the board
/FLash/QSPI_IO1: I401.8 (DQ1); also elsewhere on the board
/FLash/QSPI_IO2: I401.9 (W#/DQ2); also elsewhere on the board
/FLash/QSPI_IO3: I401.1 (DQ3/HOLD#); also elsewhere on the board
GND: I401.10 (Vss); also elsewhere on the board

Parts:
C501, C503, C505: 100nF; C_0201_0603Metric; digikey 490-5405-1-ND
C502, C504: 1uF; C_0402_1005Metric; digikey 399-4873-1-ND
U501: MPL115A1; NXP_LGA-8_3x5mm_P1.25mm_H1.2mm; digikey MPL115A1-ND
U502: ICM-20948; InvenSense_QFN-24_3x3mm_P0.4mm; digikey ICM-20948

Connections:
+3V3: C501.1, C502.2, C503.2, U501.1 (VDD), U501.4 (~SHDN), U502.8 (VDDIO), U502.13 (VDD); also elsewhere on the board
/IOConnector/MISO: U501.7 (DIN), U502.24 (SDA/SDI); also elsewhere on the board
/IOConnector/MOSI: U501.6 (DOUT), U502.9 (SDO/AD0); also elsewhere on the board
/Microprocessor/SCK: U501.8 (SCLK), U502.23 (SCL/SCLK); also elsewhere on the board
/Microprocessor/~BARO_CS: U501.5 (~CS); also elsewhere on the board
/Microprocessor/~IMU_CS: U502.22 (~CS); also elsewhere on the board
/Sensors/INT1: U502.12 (INT1); also elsewhere on the board
GND: C501.2, C502.1, C503.1, C504.2, C505.2, U501.3 (GND), U502.11 (FSYNC), U502.18 (GND), U502.20 (GND); also elsewhere on the board
unnamed: C504.1, U501.2 (CAP)
unnamed: C505.1, U502.10 (REGOUT)

Parts:
D601, D602: LED_RGBC; LED_RGB_3.5mmx2.8mm; digikey 1497-1225-1-ND
R601, R602, R603, R604, R605, R606: 270; R_0402_1005Metric; digikey A129620CT-ND

Connections:
/Microprocessor/LED1_B: R603.2; also elsewhere on the board
/Microprocessor/LED1_G: R602.2; also elsewhere on the board
/Microprocessor/LED2_B: R606.2; also elsewhere on the board
/Microprocessor/LED2_G: R605.2; also elsewhere on the board
/RGBLEDs/LED1_B: R601.2; also elsewhere on the board
/RGBLEDs/LED2_B: R604.2; also elsewhere on the board
GND: D601.4 (K), D602.4 (K); also elsewhere on the board
unnamed: D601.1 (RA), R603.1
unnamed: D601.2 (GA), R602.1
unnamed: D601.3 (BA), R601.1
unnamed: D602.1 (RA), R606.1
unnamed: D602.2 (GA), R605.1
unnamed: D602.3 (BA), R604.1

Parts:
C701: 10nF; C_0402_1005Metric; digikey 490-6326-1-ND
C702: 1uF; C_0402_1005Metric; digikey 399-4873-1-ND
C703: 4.7uF; C_0402_1005Metric; digikey 490-5915-2-ND
C704, C705, C706, C707: 100nF; C_0201_0603Metric; digikey 490-5405-1-ND
IC701: STM32G473CET6; LQFP-48-1EP_7x7mm_P0.5mm_EP3.6x3.6mm; Mouser Part Number 511-STM32G473CET6
J701: Conn_01x06; j-link_6_pin_needle
R701: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder; digikey 311-10KGRCT-ND
SW701: SW_Push; SMD_Push_Switch; digikey CKN9112CT-ND
TP701, TP702, TP703, TP704, TP705, TP706: TestPoint; Test_Point_2.67x1.02mm
U701: MAX7375AXR805; SOT-323_SC-70; digikey MAX7375AXR805+TCT-ND
Y701: SIT1533AI-H4-DCC-32.768E; SIT1533AIH4DCC32768E; Mouser Part Number 788-1533AIH4DCC32.76

Connections:
+3V3: C701.1, C702.1, C703.1, C704.1, C705.1, C706.1, IC701.21 (VDDA), IC701.24 (VDD_1), IC701.36 (VDD_2), IC701.48 (VDD_3), J701.1, R701.1, U701.1 (V+), Y701.4 (VDD); also elsewhere on the board
/FLash/CS: IC701.10 (PA2), TP702.1; also elsewhere on the board
/FLash/QSCLK: IC701.11 (PA3), TP701.1; also elsewhere on the board
/FLash/QSPI_IO0: IC701.17 (PB1), TP703.1; also elsewhere on the board
/FLash/QSPI_IO1: IC701.16 (PB0), TP704.1; also elsewhere on the board
/FLash/QSPI_IO2: IC701.15 (PA7), TP705.1; also elsewhere on the board
/FLash/QSPI_IO3: IC701.14 (PA6), TP706.1; also elsewhere on the board
/IOConnector/D1: IC701.39 (PA15); also elsewhere on the board
/IOConnector/D2: IC701.13 (PA5); also elsewhere on the board
/IOConnector/MISO: IC701.41 (PB4); also elsewhere on the board
/IOConnector/MOSI: IC701.42 (PB5); also elsewhere on the board
/IOConnector/RXD: IC701.31 (PA9); also elsewhere on the board
/IOConnector/SCL: IC701.45 (PB8-BOOT0); also elsewhere on the board
/IOConnector/SDA: IC701.44 (PB7); also elsewhere on the board
/IOConnector/TXD: IC701.32 (PA10); also elsewhere on the board
/Microprocessor/8MHz: IC701.5 (PF0-OSC_IN), U701.2 (CLOCK)
/Microprocessor/32KHz: IC701.3 (PC14-OSC32_IN), Y701.3 (CLK_OUT)
/Microprocessor/ARM: IC701.12 (PA4); also elsewhere on the board
/Microprocessor/LED1_B: IC701.28 (PB14); also elsewhere on the board
/Microprocessor/LED1_G: IC701.29 (PB15); also elsewhere on the board
/Microprocessor/LED2_B: IC701.25 (PB11); also elsewhere on the board
/Microprocessor/LED2_G: IC701.26 (PB12); also elsewhere on the board
/Microprocessor/NRST: C707.1, IC701.7 (PG10-NRST), J701.3, R701.2, SW701.1
/Microprocessor/PWM1: IC701.8 (PA0); also elsewhere on the board
/Microprocessor/PWM2: IC701.9 (PA1); also elsewhere on the board
/Microprocessor/SCK: IC701.40 (PB3); also elsewhere on the board
/Microprocessor/SWCLK: IC701.38 (PA14), J701.4
/Microprocessor/SWDIO: IC701.37 (PA13), J701.2
/Microprocessor/USART_CTS: IC701.33 (PA11); also elsewhere on the board
/Microprocessor/USART_RTS: IC701.34 (PA12); also elsewhere on the board
/Microprocessor/~BARO_CS: IC701.46 (PB9); also elsewhere on the board
/Microprocessor/~IMU_CS: IC701.2 (PC13); also elsewhere on the board
/RGBLEDs/LED1_B: IC701.30 (PA8); also elsewhere on the board
/RGBLEDs/LED2_B: IC701.27 (PB13); also elsewhere on the board
/Robotics/FIRE1: IC701.18 (PB2); also elsewhere on the board
/Robotics/FIRE2: IC701.22 (PB10); also elsewhere on the board
/Sensors/INT1: IC701.43 (PB6); also elsewhere on the board
GND: C701.2, C702.2, C703.2, C704.2, C705.2, C706.2, C707.2, IC701.19 (VSSA), IC701.23 (VSS_1), IC701.35 (VSS_2), IC701.47 (VSS_3), J701.5, SW701.2, U701.3 (GND), Y701.2 (GND); also elsewhere on the board

Notes on the sheet:
Decoupling capacitors for Power, see manual for chip page 77 for where to place each of them
dont forget to wire VRef
Dont forget to wire VBat
SWD reset decoupling, and reset button
Occilators
I2C Pullups?

Parts:
C801, C802: 27pF; C_0402_1005Metric; digikey 490-11384-1-ND
D801: D_Schottky; D_SOD-323_HandSoldering; digikey BAT54HT1GOSCT-ND
D802: D; D_SOD-323; digikey BAT54HT1GOSCT-ND
D803: LEDY; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder; digikey 160-1448-1-ND
D804: LEDG; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder; digikey 160-1478-1-ND
J801: USB_C_Receptacle; USB_C_Receptacle_USB4110; digikey 2073-USB4110-GF-A-1-ND
J802, J803: Conn_01x10; PinHeader_1x10_P2.54mm_Vertical; digikey 609-3250-ND
R801, R802: 5k; C_0402_1005Metric; digikey 541-1901-1-ND
R803, R804: 27; R_0402_1005Metric; digikey P27.0LCT-ND
R805, R806, R807, R808: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder; digikey 311-10KGRCT-ND
R809, R810: 270; R_0402_1005Metric; digikey A129620CT-ND
U801: FT230XS; SSOP-16_3.9x4.9mm_P0.635mm; digikey 768-1135-1-ND

Connections:
+3V3: D802.1 (K), J803.8, J803.9, J803.10, R805.1, R806.1, R807.1, R808.1, R809.1, R810.2, U801.3 (VCCIO), U801.11 (~RESET); also elsewhere on the board
+5V: D801.1, J803.5, J803.6, J803.7; also elsewhere on the board
/IOConnector/D1: J802.5; also elsewhere on the board
/IOConnector/D2: J802.4; also elsewhere on the board
/IOConnector/MISO: J802.6; also elsewhere on the board
/IOConnector/MOSI: J802.7; also elsewhere on the board
/IOConnector/RXD: R806.2, U801.4 (RXD); also elsewhere on the board
/IOConnector/SCL: J802.9; also elsewhere on the board
/IOConnector/SDA: J802.10; also elsewhere on the board
/IOConnector/TXD: R805.2, U801.1 (TXD); also elsewhere on the board
/IOConnector/USBD+: C802.1, J801.A6 (D+), J801.B6 (D+), R804.2
/IOConnector/USBD-: C801.1, J801.A7 (D-), J801.B7 (D-), R803.2
/Microprocessor/SCK: J802.8; also elsewhere on the board
/Microprocessor/USART_CTS: R807.2, U801.2 (~RTS); also elsewhere on the board
/Microprocessor/USART_RTS: R808.2, U801.6 (~CTS); also elsewhere on the board
GND: C801.2, C802.2, J801.A1 (GND), J801.A12 (GND), J801.B1 (GND), J801.B12 (GND), J802.1, J802.2, J802.3, J803.1, J803.2, J803.3, J803.4, R801.2, R802.2, U801.5 (GND), U801.13 (GND); also elsewhere on the board
unnamed: D802.2 (A), U801.10 (3V3OUT)
unnamed: D803.1 (K), U801.14 (CBUS1)
unnamed: D803.2 (A), R809.2
unnamed: D804.1 (K), U801.7 (CBUS2)
unnamed: D804.2 (A), R810.1
unnamed: J801.A5 (CC1), R801.1
unnamed: J801.B5 (CC2), R802.1
unnamed: R803.1, U801.9 (USBDM)
unnamed: R804.1, U801.8 (USBDP)
VBUS: D801.2, J801.A4 (VBUS), J801.A9 (VBUS), J801.B4 (VBUS), J801.B9 (VBUS), U801.12 (VCC)

Notes on the sheet:
see https://www.scorpia.co.uk/2016/03/17/using-usb-type-c-on-hobyist-projects/

Board: 4 copper layers, 44.0 x 67.5 mm, 82 parts (36 on the bottom side), 67 nets.

## Code that names these connections

File RedBoard_Software/RedBoard.ioc (part):

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Mcu.Name=STM32G473C(B-C-E)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32G473CETx
PA0.GPIOParameters=GPIO_Label
PA0.GPIO_Label=SERVO1
PA0.Signal=GPIO_Output
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=SERVO2
PA1.Signal=GPIO_Output
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA11.Mode=CTS_RTS
PA11.Signal=USART1_CTS
PA12.Mode=CTS_RTS
PA12.Signal=USART1_RTS
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=GPIO_Label
PA15.GPIO_Label=D1
PA15.Signal=GPIO_Output
PA2.Mode=Single Bank 1
PA2.Signal=QUADSPI1_BK1_NCS
PA3.Mode=Single Bank 1
PA3.Signal=QUADSPI1_CLK
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=ARM
PA4.Signal=GPIO_Output
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=D2
PA5.Signal=GPIO_Output
PA6.Mode=Single Bank 1
PA6.Signal=QUADSPI1_BK1_IO3
PA7.Mode=Single Bank 1
PA7.Signal=QUADSPI1_BK1_IO2
PA8.GPIOParameters=GPIO_Label
PA8.GPIO_Label=LED1_R
PA8.Signal=GPIO_Output
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB0.Mode=Single Bank 1
PB0.Signal=QUADSPI1_BK1_IO1
PB1.Mode=Single Bank 1
PB1.Signal=QUADSPI1_BK1_IO0
PB10.GPIOParameters=GPIO_Label
PB10.GPIO_Label=FIRE_2
PB10.Signal=GPIO_Output
PB11.GPIOParameters=GPIO_Label
PB11.GPIO_Label=LED2_B
PB11.Signal=GPIO_Output
PB12.GPIOParameters=GPIO_Label
PB12.GPIO_Label=LED2_G
PB12.Signal=GPIO_Output
PB13.GPIOParameters=GPIO_Label
PB13.GPIO_Label=LED2_R
PB13.Signal=GPIO_Output
PB14.GPIOParameters=GPIO_Label
PB14.GPIO_Label=LED1_B
PB14.Signal=GPIO_Output
PB15.GPIOParameters=GPIO_Label
PB15.GPIO_Label=LED1_G
PB15.Signal=GPIO_Output
PB2.GPIOParameters=GPIO_Label
PB2.GPIO_Label=FIRE_1
PB2.Signal=GPIO_Output
PB3.Mode=Full_Duplex_Master
PB3.Signal=SPI1_SCK
PB4.Mode=Full_Duplex_Master
PB4.Signal=SPI1_MISO
PB5.Mode=Full_Duplex_Master
PB5.Signal=SPI1_MOSI
PB6.GPIOParameters=GPIO_Label
PB6.GPIO_Label=D3
PB6.Signal=GPIO_Output
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
PB8-BOOT0.Mode=I2C
PB8-BOOT0.Signal=I2C1_SCL
PB9.GPIOParameters=GPIO_Label
PB9.GPIO_Label=BARO_CS
PB9.Signal=GPIO_Output
PC13.GPIOParameters=GPIO_Label
PC13.GPIO_Label=IMU_CS
PC13.Signal=GPIO_Output
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=16000000
board=custom

## Commit log

2020-05-22 Moving Work to Github
2020-05-22 Created git ignore, and added sch-bak files to it
2020-05-22 updated git ignore so it would actually work and applied it retroactively
2020-05-22 removed gerber files
2020-05-22 Made one library in the project folder with all symbols and footprints for easy sharing
2020-05-23 updated documentation and fixed a few minor erros
2020-05-23 Post design review
2020-05-24 Changed Silkscreen to accurately reflect pinout
2020-05-24 Few minor silkscreen changes
2020-05-26 Swapped USBC connector out for one that was available, minor Silkscreen tweaks
2020-05-26 Final Manufacturing Modifactions for Version 1.0
2020-06-01 update Gitignore
    Created a gitignore that removes all unneded files from KiKad
2020-06-02 retroactively applied .gitignore
2020-06-02 oops missed one
2020-06-20 Created schematic changes for Red V1.1
2020-06-20 Added footprint for diode and reannoted schematics
2020-06-20 Fixed a footprint error for the 32k clk
2020-06-21 Created V1.1 Layout, minor schematic updates
2020-06-21 Final Red V1.1 changers
2020-06-22 minor fixes
